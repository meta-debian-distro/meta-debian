SRC_URI = "${MISC_GIT_URI}/${MISC_GIT_PREFIX}${BPN}.git;protocol=${MISC_GIT_PROTOCOL} \
file://fallback-passwd \
file://fallback-group \
"
SRCREV = "${AUTOREV}"
SRC_REV="735ac1b9ff7471b100f6758f9072bfd45e0e3f40"
