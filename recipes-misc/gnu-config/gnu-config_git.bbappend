SRC_URI = "${MISC_GIT_URI}/${MISC_GIT_PREFIX}${BPN}.git;protocol=${MISC_GIT_PROTOCOL} \
           file://gnu-configize.in \
          "
SRC_REV="b576fa87c140b824466ef1638e945e87dc5c0343"
