require x11-xserver-utils.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ef598adbe241bd0b0b9113831f6e249a"

S = "${DEBIAN_UNPACK_DIR}/rgb"
SRC_REV="c86bab69cb1d17627a397ac81047348bcb050317"
