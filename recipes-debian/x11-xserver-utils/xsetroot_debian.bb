require x11-xserver-utils.inc

DESCRIPTION = "a tool for tailoring the appearance of the root window"

LIC_FILES_CHKSUM = "file://COPYING;md5=6ea29dbee22324787c061f039e0529de"

S = "${DEBIAN_UNPACK_DIR}/xsetroot"
SRC_REV="c86bab69cb1d17627a397ac81047348bcb050317"
